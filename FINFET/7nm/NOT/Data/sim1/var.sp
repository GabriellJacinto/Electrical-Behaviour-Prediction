.temp -25.0 0.0 25.0 50.0 75.0 100.0
simulator lang=spectre
parameters vdd=0.7
parameters vss=0
parameters number_fin = 1
parameters LoadCap = 1f
