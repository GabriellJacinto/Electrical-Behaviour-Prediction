.temp 25.0
simulator lang=spectre
parameters Vin=0.7
parameters vss=0
parameters number_fin = 1
parameters load = 1f
parameters passo = 0.01n
parameters t_pulse = 10n
parameters dl = 0.1p
